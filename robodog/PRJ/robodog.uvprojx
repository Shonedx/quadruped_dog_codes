# Keil uVision project robodog.uvprojx, settings and files
target PRJ (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: robodog
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Drivers\Core;..\Drivers\Library\inc;..\APP\Kalman;..\APP\MotionCtrl;..\APP\Motor;..\APP\PID;..\APP\RC;..\BSP\CAN;..\BSP\IMU;..\BSP\IWDG;..\BSP\LED;..\BSP\OLED;..\BSP\OLED_IIC;..\BSP\RC_NRF24L01;..\BSP\RC_SPI;..\BSP\Timer;..\BSP\System\inc;.\MAIN
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group IMU
    ../BSP/IMU/: imu.c imu.h
  group IWDG
    ../BSP/IWDG/: iwdg.c iwdg.h
  group OLED_IIC
    ../BSP/OLED_IIC/: oled_iic.c oled_iic.h
  group RC_NRF24L01
    ../BSP/RC_NRF24L01/: rc_nrf24l01.c rc_nrf24l01.h
  group RC_SPI
    ../BSP/RC_SPI/: rc_spi.c rc_spi.h
  group CAN
    ../BSP/CAN/: can.c can.h
  group MAIN
    ./MAIN/: main.c main.h
  group System
    ../BSP/System/src/: delay.c sys.c usart.c
    ../BSP/System/inc/: delay.h sys.h usart.h
  group Timer
    ../BSP/Timer/: timer.c timer.h
  group Kalman
    ../APP/Kalman/: kalman.c kalman.h
  group MotionCtrl
    ../APP/MotionCtrl/: gaitparams.c gaitparams.h jump.c jump.h motion_ctrl.c motion_ctrl.h
  group Motor
    ../APP/Motor/: motor.c motor.h
  group PID
    ../APP/PID/: pid.c pid.h
  group RC
    ../APP/RC/: rc.c rc.h
  group OLED
    ../BSP/OLED/: font.c font.h oled.c oled.h
