# Keil uVision project 四足.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 四足
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\Core;.\Hardware\CAN;.\Hardware\PID;.\Library\inc;.\System\delay;.\System\sys;.\System\usart;.\User;.\User\ges_cal;.\User\IMU;.\User\IWDG;.\User\Remote_Ctrl;.\User\Time_ctrl;.\Hardware\LED;.\Hardware\MOTOR;.\Hardware\Karlman;.\Hardware\OLED
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: Allheaderfile.h main.c main.h main_params.h
  group Hardware
    ./Hardware/CAN/: can.c can.h
    ./Hardware/PID/: pid.c pid.h
    ./Hardware/LED/: led.c led.h
    ./Hardware/MOTOR/: motor.c motor.h
    ./Hardware/OLED/: IIC_OLED.h IIC_OLED.c OLED.h OLED.c font.h font.c
    ./User/ges_cal/: Jump.c Jump.h
  group ges_cal
    ./User/ges_cal/: GaitParams.c GaitParams.h ges_cal.c ges_cal.h
  group imu
    ./User/IMU/: IMU.c IMU.h Kalman.c Kalman.h MPU6050.c MPU6050.h
  group iwdg
    ./User/IWDG/: IWDG.c IWDG.h
  group remote_ctrl
    ./User/Remote_Ctrl/: RC_Command.c RC_Command.h RemoteControl_Init.c RemoteControl_Init.h NRF24L01.h NRF20L01.c RC.c RC.h
  group time_ctrl
    ./User/Time_ctrl/: ticks.c ticks.h timer.c timer.h
  group System
    ./System/delay/: delay.c delay.h
    ./System/sys/: sys.c sys.h
    ./System/usart/: usart.c usart.h
  group Core
    ./Core/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f40_41xxx.s
  group Library
    ./Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_it.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c
