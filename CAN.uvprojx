# Keil uVision project CAN.uvprojx, settings and files
target CAN (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAN +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;C:\Keil_v5\ARM\ARMCC\include;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;.\ges_cal;.\IMU;.\IWDG;.\Remote_Ctrl;.\Time_ctrl;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\PID;..\HARDWARE\CAN;..\HARDWARE\PSTWO
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c main_params.h
  group HARDWARE
    ../HARDWARE/PID/: pid.c pid.h
    ../HARDWARE/CAN/: can.c can.h
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/LED/: led.c led.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_tim.c
    ./: stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_iwdg.c
  group README
    ../: readme.txt
  group IMU
    ./IMU/: IMU.c IMU.h
  group Ges_Cal
    ./ges_cal/: ges_cal.c ges_cal.h GaitParams.h GaitParams.c Jump.c Jump.h
  group IWDG
    ./IWDG/: IWDG.c IWDG.h
  group Time_Ctrl
    ./Time_ctrl/: ticks.c ticks.h timer.c timer.h
  group Remote_Ctrl
    ./Remote_Ctrl/: RC_Command.c RC_Command.h RemoteControl_Init.c RemoteControl_Init.h
